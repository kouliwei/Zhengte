# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F207VETx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 wLevel=2
  c define: USE_FULL_ASSERT USE_STDPERIPH_DRIVER
  c include: .\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\STM32F2xx_StdPeriph_Driver\inc;.\User;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;.\demo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ./User/: main.c stm32f2xx_it.c system_stm32f2xx.c
  group mdk-arm
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group startup
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/arm/: startup_stm32f2xx.s
  group stm32_perish_driver
    ./Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_syscfg.c stm32f2xx_usart.c stm32f2xx_exti.c stm32f2xx_tim.c stm32f2xx_adc.c stm32f2xx_dma.c stm32f2xx_dac.c stm32f2xx_pwr.c stm32f2xx_i2c.c stm32f2xx_flash.c stm32f2xx_iwdg.c
    ./demo/: i2c.c
  group demo
    ./demo/: common.c usart.c test.c nvic.c time.c adc.c pwr.c motor.c senser.c abnormal.c car.c flash.c lcd_key.c
